
IMAGE_INSTALL_append += " flash-fuse intel-eeprom-access-tool loopback-test test-framework"