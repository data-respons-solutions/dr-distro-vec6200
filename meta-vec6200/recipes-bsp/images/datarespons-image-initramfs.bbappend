
IMAGE_INSTALL_append += " flash-fuse"